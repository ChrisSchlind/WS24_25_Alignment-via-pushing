Commit message: Edited T Object and fixed double T Object

File: data/assets/objects/double_t/object.urdf (robot description, URDF)
Before this commit: robot double_t, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.025 0.08 0.05; collision box size=0.08 0.025 0.05
